# Keil uVision project empty_LP_MSPM0G3519_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3519_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3519 Texas Instruments
  pack: TexasInstruments.MSPM0GX51X_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20100000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x00400000,0x00080000) XRAM(0x20200000,0x00020000) XRAM2(0x20300000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty +hex
  BeforeMake: cmd.exe /C "$P../tools/keil/syscfg.bat '$P../entrance' empty.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3519__
  c include: ..\source;..\freertos-source\include;..\source\third_party\CMSIS\Core\Include;..\entrance;..\BSP;..\algorithm;..\source\third_party\CMSIS\DSP\Include;..\user
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x80000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20100000 size 0x10000
  scatter file: .\mspm0g3519.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0gx51x/driverlib.a
  group Source
    ../source/ti/driverlib/: dl_adc12.c dl_adc12.h dl_aes.c dl_aes.h dl_aesadv.c dl_aesadv.h dl_common.c dl_common.h dl_comp.c dl_comp.h dl_crc.c dl_crc.h dl_crcp.c dl_crcp.h dl_dac12.c dl_dac12.h dl_dma.c dl_dma.h dl_flashctl.c dl_flashctl.h dl_gpamp.c dl_gpamp.h dl_gpio.c dl_gpio.h dl_i2c.c dl_i2c.h dl_i2s.c dl_i2s.h dl_iwdt.c dl_iwdt.h dl_keystorectl.c dl_keystorectl.h dl_lcd.c dl_lcd.h dl_lfss.c dl_lfss.h dl_mathacl.c dl_mathacl.h dl_mcan.c dl_mcan.h dl_npu.c dl_npu.h dl_opa.c dl_opa.h dl_rtc.c dl_rtc.h dl_rtc_a.c dl_rtc_a.h dl_rtc_b.c dl_rtc_b.h dl_rtc_common.c dl_rtc_common.h dl_scratchpad.c dl_scratchpad.h dl_spgss.c dl_spgss.h dl_spi.c dl_spi.h dl_tamperio.c dl_tamperio.h dl_timer.c dl_timer.h dl_timera.c dl_timera.h dl_timerb.c dl_timerb.h dl_timerg.c dl_timerg.h dl_trng.c dl_trng.h dl_uart.c dl_uart.h dl_uart_extend.h dl_uart_main.h dl_unicomm.c dl_unicomm.h dl_unicommi2cc.c dl_unicommi2cc.h dl_unicommi2ct.c dl_unicommi2ct.h dl_unicommspi.c dl_unicommspi.h dl_unicommuart.c dl_unicommuart.h dl_vref.c dl_vref.h dl_wwdt.c dl_wwdt.h driverlib.h
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0gx51x.c
  group freertos
    ../freertos-source/: croutine.c event_groups.c heap_4.c list.c port.c portasm.c queue.c stream_buffer.c tasks.c timers.c
  group entrance
    ../entrance/: empty.c ti_msp_dl_config.c startup_mspm0g351x_uvision.s empty.syscfg FreeRTOSConfig.h
    ../source/third_party/CMSIS/DSP/lib/keil/m0p/: arm_cortexM0l_math.a
  group bsp
    ../BSP/led/: timerG6_pwm_rgb.c
    ../BSP/imu/: icm42688.c icm.c icm.h icm42688.h
    ../BSP/timer/: timer.c
    ../BSP/oled/: oled.c oled.h oledfont.h
  group alog
    ../algorithm/: controller.c crc8.c crc16.c kalman_filter.c QuaternionEKF.c user_lib.c pid.c
  group User
    ../user/: GraySensor.c motor.c
